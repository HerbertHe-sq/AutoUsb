# Keil uVision project test.uvproj, settings and files
target AutoUsb (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: test +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F0XX
  c include: ..\lib\inc;..\startup;..\user;..\lib\src;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../user/: main.c stm32f0xx_it.c system_stm32f0xx.c game.c dev_func.c
    ../drive/: user.c
  group STARTUP
    ../startup/: core_cm3.c startup_stm32f0xx.s
  group LIB
    ../lib/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group DRIVE
    ../drive/: delay.c switch.c ble.c 24cl02.c eepiic.c oled.c ds1302.c flash.c itemp.c
    ../user/: ds18b20.c
